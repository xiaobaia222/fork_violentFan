# Keil uVision project fan_fork.uvproj, settings and files
target fan_fork (MCS-51)
  device: STC8H1K08 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x03FF) IROM(0-0x1FF8) CLOCK(35000000)
  output: fan_fork +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51
  group src
    ./src/: main.c motor.c led.c common.c
